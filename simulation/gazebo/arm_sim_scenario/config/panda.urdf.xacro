Commit message: updates

File: simulation/gazebo/arm_sim_scenario/config/panda.urdf.xacro (robot description, xacro)
@@ -15,5 +15,5 @@
         <parent link="world" />
         <child link="random" />
-        </joint>
+    </joint>
     <link name="random"/>
     <link name="ground_plane_box">
